LINUX_VERSION = "5.4"

include linux-zynq7000.inc
include linux-zynq7000_dts.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=bbea815ee2795b2f4230826c0c6b8814"


